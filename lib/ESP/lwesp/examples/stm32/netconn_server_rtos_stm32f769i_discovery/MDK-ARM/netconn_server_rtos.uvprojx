# Keil uVision project netconn_server_rtos.uvprojx, settings and files
target Netconn_Server_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Netconn_Server_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F769xx
  c include: ..\inc;..\..\..\..\libs;..\..\..\..\third_party\Embedded_Libs\st_hal\STM32F7xx_HAL_Driver\Inc;..\..\..\..\third_party\Embedded_Libs\st_hal\CMSIS\Include;..\..\..\..\third_party\Embedded_Libs\st_hal\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\CMSIS_RTOS;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\include;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\snippets\include;..\..\..\..\ESP_AT_Lib\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group MDK-ARM
    ./: startup_stm32f769xx.s
  group CMSIS
    ../Src/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../../../third_party/Embedded_Libs/st_hal/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
  group FreeRTOS
    ../../../../third_party/Embedded_Libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/portable/RVDS/ARM_CM7/: port_cm7.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
  group ESP CORE
    ../../../../ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c esp_utils.c esp_dns.c
  group ESP API
    ../../../../ESP_AT_Lib/src/api/: esp_netconn.c
  group ESP LL
    ../../../../ESP_AT_Lib/src/system/: esp_ll_stm32f769i_discovery.c esp_sys_cmsis_os.c
  group ESP SNIPPETS
    ../../../../snippets/: station_manager.c netconn_server.c
  group User
    ../Src/: stm32f7xx_it.c main.c
