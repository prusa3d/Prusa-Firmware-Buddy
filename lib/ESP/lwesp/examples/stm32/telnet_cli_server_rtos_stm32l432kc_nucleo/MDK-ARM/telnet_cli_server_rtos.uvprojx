# Keil uVision project telnet_cli_server_rtos.uvprojx, settings and files
target Telnet_CLI_Server_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Telnet_CLI_Server_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L432xx
  c include: ..\inc;..\..\..\..\libs;..\..\..\..\third_party\Embedded_Libs\st_hal\STM32L4xx_HAL_Driver\Inc;..\..\..\..\third_party\Embedded_Libs\st_hal\CMSIS\Include;..\..\..\..\third_party\Embedded_Libs\st_hal\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\CMSIS_RTOS;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\include;..\..\..\..\third_party\Embedded_Libs\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\..\..\snippets\include;..\..\..\..\ESP_AT_Lib\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group MDK-ARM
    ./: startup_stm32l432xx.s
  group CMSIS
    ../src/: system_stm32l4xx.c
  group STM32L4xx_HAL_Driver
    ../../../../third_party/Embedded_Libs/st_hal/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group FreeRTOS
    ../../../../third_party/Embedded_Libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
    ../../../../third_party/Embedded_Libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
  group ESP CORE
    ../../../../ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_cli.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c esp_utils.c esp_dns.c
  group ESP API
    ../../../../ESP_AT_Lib/src/api/: esp_netconn.c
  group ESP LL
    ../../../../ESP_AT_Lib/src/system/: esp_sys_cmsis_os.c esp_ll_stm32l432kc_nucleo.c
  group ESP SNIPPETS
    ../../../../snippets/: station_manager.c netconn_server.c telnet_server.c
    ../../../../ESP_AT_Lib/src/cli/: cli.c cli_input.c
  group User
    ../Src/: main.c
    ../src/: stm32l4xx_it.c
